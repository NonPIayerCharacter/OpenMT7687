# IAR project iot_sdk_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DATA_PATH_87; E2_ROM_7682; FREERTOS_ENABLE; FREERTOS_VERSION=V10_AND_LATER; MBEDTLS_CONFIG_FILE=<config-mtk-md5.h>; MT5932_SINGLE_CONTEXT; MT7686_E2_ENABLE; MTK_AT_CMD_DISABLE; MTK_BLE_BQB_CLI_ENABLE; MTK_BLE_CLI_ENABLE; MTK_BLE_SMTCN_ENABLE; MTK_BT_LWIP_ENABLE; MTK_BWCS_ENABLE; MTK_CLI_TEST_MODE_ENABLE; MTK_CM4_N9_SINGLE_IMG; MTK_CM4_WIFI_TASK_ENABLE; MTK_DEBUG_LEVEL_ERROR; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_HAL_LOWPOWER_ENABLE; MTK_HIF_GDMA_ENABLE; MTK_HIF_HEADER_2DW; MTK_IPERF_ENABLE; MTK_LWIP_ENABLE; MTK_MINICLI_ENABLE; MTK_NVDM_ENABLE; MTK_OS_CLI_ENABLE; MTK_OS_CPU_UTILIZATION_ENABLE; MTK_PING_OUT_ENABLE; MTK_ROM_VER=e2; MTK_SMTCN_V4_ENABLE; MTK_SMTCN_V5_ENABLE; MTK_WIFI_CLI_ENABLE; MTK_WIFI_ENABLE; MTK_WIFI_PMF_ENABLE; MTK_WIFI_PROFILE_ENABLE; MTK_WIFI_REPEATER_ENABLE; MTK_WIFI_ROM_ENABLE; MTK_WIFI_STA_CSA_ENABLE; MTK_WIFI_WPA3_SAE_ENABLE; MTK_WIFI_WPS_ENABLE; PCFG_OS=2; PMKSA_ENABLE; PRODUCT_VERSION=7698; USE_HAL_DRIVER; WSC_V2_SUPPORT; _REENT_SMALL; __BT_DEBUG__; __MTK_BLE_ONLY_ENABLE__; uECC_ENABLE_VLI_API=1; uECC_OPTIMIZATION_LEVEL=2; uECC_SQUARE_FUNC=1; uECC_SUPPORTS_secp160r1=0; uECC_SUPPORTS_secp192r1=1; uECC_SUPPORTS_secp224r1=0; uECC_SUPPORTS_secp256k1=0; uECC_SUPPORTS_secp256r1=1; uECC_SUPPORT_COMPRESSED_POINT=1; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\CMSIS\Device\airoha\aw7698\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\board\aw7698_evk\ept\inc; ..\..\..\..\..\driver\board\aw7698_evk\util\inc; ..\..\..\..\..\driver\chip\aw7698\inc; ..\..\..\..\..\driver\chip\aw7698\src\common\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\aw7698; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\offline_dump\inc; ..\..\..\..\..\kernel\service\swla\inc; ..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\kernel\service\systemhang_tracer\inc; ..\..\..\..\..\middleware\MTK\bluetooth\inc; ..\..\..\..\..\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\middleware\MTK\bwcs\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm_core\inc_core; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\wifi_service\bwcs\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\micro_ecc\inc; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\FreeRTOS; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\third_party\sntp\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\inc\pse; ..\..\..\..\..\project\aw7698_evk\apps\iot_sdk_demo\src\ut_app; ..\..\..\..\..\project\common\bsp_ex\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: iot_sdk_demo.bin
  ILINK.IlinkOutputFile: iot_sdk_demo.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; -f ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\symboldef_link.h
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bluetooth
    ../../../../../middleware/MTK/bluetooth/src/: bt_cli.c bt_debug.c bt_hci_log.c bt_log.c bt_os_layer_api.c bt_task.c
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libble_iar.a libble_multi_adv_iar.a libbtdriver_7698_iar.a
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group bwcs
    ../../../../../middleware/MTK/bwcs/src/: bwcs.c bwcs_api.c bwcs_bt_interface.c bwcs_wifi_interface.c
  group connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_log.c connsys_util.c mt7686_ram_release_flash.c uart_slim_version.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver/board
    ../../../../../driver/board/aw7698_evk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/aw7698_evk/util/src/: board_cli.c gpio_cli.c io_def.c sleep_manager_cli.c
  group driver/chip
    ../../../../../driver/chip/aw7698/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_clock.c hal_dcxo.c hal_des.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2s.c hal_i2s_internal.c hal_log.c hal_md5.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_sdio_slave.c hal_sdio_slave_internal.c hal_security.c hal_sha.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_sys.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_wdt.c hal_wdt_internal.c hal_weak.c
    ../../../../../prebuilt/driver/chip/aw7698/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_cli.c iperf_task.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/aw7698/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/service/offline_dump/src/: offline_dump.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/service/swla/src/: swla.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
    ../../../../../kernel/service/systemhang_tracer/src/: systemhang_tracer.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c sys_arch.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aes_alt.c
  group micro_ecc
    ../../../../../middleware/third_party/micro_ecc/src/: uECC.c
  group minicli
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
  group nvkey
    ../../../../../tools/iar/aw7698/nvkey/: nvkey.c
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
  group project/app
    ../../../../../project/aw7698_evk/apps/iot_sdk_demo/src/: ble_smtcn.c ble_throughput.c bt_init.c cli_cmds.c cli_def.c ept_eint_var.c ept_gpio_var.c hci_log.c main.c mem_layout_info.c network_default_config.c nvdm_config.c regions_init.c sys_init.c system_aw7698.c wifi_lwip_helper.c wifi_nvdm_config.c
    ../../../../../project/aw7698_evk/apps/iot_sdk_demo/src/ut_app/: bt_lwip.c connection_info.c gatt_command.c gatt_service.c ut_app.c ut_app_gap.c
    ./: startup_aw7698.s
  group pwr
    ../../../../../tools/iar/aw7698/pwr/: mt768x_default_PerRate_TxPwr.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c elian.c ops_config.c smt_api.c smt_conn.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_IAR.a libmcsmtcn_CM4_IAR.a
  group wifi_service
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c single_rate_test.c wifi_bwcs_porting.c wifi_cli.c wifi_cm4_scan.c wifi_inband_cli.c wifi_log.c wifi_os_api.c wifi_private_cli.c wifi_profile.c wifi_repeater.c wifi_wps.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_inic/: libwifi_CM4_IAR.a
  group wifi_stack
    ../../../../../prebuilt/middleware/MTK/wifi_stack/lib/: libwifi_ram_CM4_repeater_wps_IAR.a
