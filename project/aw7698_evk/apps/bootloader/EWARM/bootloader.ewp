# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_BOOTLOADER_SUPPORT_PARTITION_FOTA; BL_LOAD_ENABLE; BL_FOTA_ENABLE; BL_DEBUG; MTK_BL_DEBUG_ENABLE; MTK_FOTA_ENABLE; BL_FOTA_DEBUG; MOD_CFG_FOTA_BL_RESERVED; MTK_BL_LOAD_ENABLE; MOD_CFG_FOTA_BL_RESERVED; MOD_CFG_FOTA_DISABLE_CLI; MOD_CFG_FOTA_DISABLE_OS; __UBL__; MTK_BOOTLOADER_USE_MBEDTLS; __EXT_BOOTLOADER__; MTK_FOTA_ON_7698; MTK_FOTA_ON_7686; MBEDTLS_CONFIG_FILE=<config-mtk-sha1.h>
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\airoha\aw7698\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\aw7698\inc; ..\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\lzma_decoder\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\fota\inc\internal; ..\..\..\..\..\middleware\MTK\fota\inc\common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkKeepSymbols: __vector_table
  group bootloader
    ../src/: bl_dbgprint.c bl_fota.c custom_blconfig.c main.c system_aw7698.c
    ./: startup_aw7698.s
  group fota
    ../../../../../middleware/MTK/fota/src/internal/: fota_config.c fota_internal.c fota_port.c
    ../../../../../middleware/MTK/fota/src/common/: fota_platform.c
  group hal
    ../../../../../driver/chip/aw7698/src/: hal_cache.c hal_cache_internal.c hal_clock.c hal_dcxo.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpt.c hal_gpt_internal.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_uart.c hal_uart_internal.c hal_wdt.c hal_wdt_internal.c
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group sha1
    ../../../../../middleware/third_party/mbedtls/library/: sha1.c sha1_alt.c
