# IAR project minicli.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DATA_PATH_87; E2_ROM_7682; FREERTOS_ENABLE; FREERTOS_VERSION=V10_AND_LATER; MT5932_SINGLE_CONTEXT; MT7686_E2_ENABLE; MTK_CM4_N9_SINGLE_IMG; MTK_CM4_WIFI_TASK_ENABLE; MTK_DEBUG_LEVEL_ERROR; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_HIF_GDMA_ENABLE; MTK_HIF_HEADER_2DW; MTK_LWIP_ENABLE; MTK_MINICLI_ENABLE; MTK_NO_PSRAM_ENABLE; MTK_ROM_VER=e2; MTK_WIFI_CLI_ENABLE; MTK_WIFI_ROM_ENABLE; PCFG_OS=2; PRODUCT_VERSION=7686; USE_HAL_DRIVER; _REENT_SMALL
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\driver\board\mt7686_hdk\util\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\mt7686; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\offline_dump\inc; ..\..\..\..\..\kernel\service\swla\inc; ..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\kernel\service\systemhang_tracer\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\third_party\chacha20poly1305\inc; ..\..\..\..\..\middleware\third_party\curve25519\inc; ..\..\..\..\..\middleware\third_party\ed25519\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\FreeRTOS; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\third_party\sntp\inc; ..\..\..\..\..\middleware\third_party\srp\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\project\mt7686_hdk\apps\minicli\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: minicli.bin
  ILINK.IlinkOutputFile: minicli.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; -f ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\symboldef_link.h
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver/board
    ../../../../../driver/board/mt7686_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt7686_hdk/util/src/: board_cli.c gpio_cli.c io_def.c sleep_manager_cli.c
  group driver/chip
    ../../../../../driver/chip/mt7686/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_clock.c hal_dcxo.c hal_des.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2s.c hal_i2s_internal.c hal_log.c hal_md5.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_sdio_slave.c hal_sdio_slave_internal.c hal_security.c hal_sha.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_sys.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_wdt.c hal_wdt_internal.c
    ../../../../../prebuilt/driver/chip/mt7686/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7686/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/service/offline_dump/src/: offline_dump.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/service/swla/src/: swla.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
    ../../../../../kernel/service/systemhang_tracer/src/: systemhang_tracer.c
  group minicli
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
  group project/app
    ../../../../../project/mt7686_hdk/apps/minicli/src/: ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c system_mt7686.c
    ./: startup_mt7686.s
  group pwr
    ../../../../../tools/iar/mt7686/pwr/: mt768x_default_PerRate_TxPwr.c
  group wifi_stack
    ../../../../../prebuilt/middleware/MTK/wifi_stack/lib/: libwifi_ram_CM4_IAR.a
