# IAR project aws_iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AWS_IOT_TEST_ENABLE; DATA_PATH_87; ENABLE_IOT_DEBUG; ENABLE_IOT_ERROR; ENABLE_IOT_INFO; ENABLE_IOT_WARN; FREERTOS_ENABLE; FREERTOS_VERSION=V10_AND_LATER; MBEDTLS_CONFIG_FILE=<config-aws-iot.h>; MTK_BSPEXT_ENABLE; MTK_DEBUG_LEVEL_DEBUG; MTK_DEBUG_LEVEL_ERROR; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_EXTERNAL_FLASH_ENABLE; MTK_FLASH_DIRECT_DL; MTK_HAL_LOWPOWER_ENABLE; MTK_HIF_GDMA_ENABLE; MTK_LWIP_ENABLE; MTK_MINISUPP_ENABLE; MTK_NVDM_ENABLE; MTK_PATCH_DL_ENABLE; MTK_WIFI_CLI_ENABLE; MTK_WIFI_TGN_VERIFY_ENABLE; PCFG_OS=2; PRODUCT_VERSION=7697; SUPPORT_MBEDTLS; USE_HAL_DRIVER; _REENT_SMALL
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\offline_dump\inc; ..\..\..\..\..\kernel\service\swla\inc; ..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\kernel\service\systemhang_tracer\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm_core\inc_core; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\third_party\aws_iot\external_libs\jsmn; ..\..\..\..\..\middleware\third_party\aws_iot\include; ..\..\..\..\..\middleware\third_party\aws_iot\platform\freertos; ..\..\..\..\..\middleware\third_party\aws_iot\samples\freertos; ..\..\..\..\..\middleware\third_party\aws_iot\tests\freertos_integration\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc\; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\project\common\certs\aws; ..\..\..\..\..\project\mt7697_hdk\apps\aws_iot\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: aws_iot.bin
  ILINK.IlinkOutputFile: aws_iot.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group N9
    ../../../../../tools/iar/mt7687/N9/: mt76X7_n9_image.c
  group aws_iot
    ../../../../../middleware/third_party/aws_iot/external_libs/jsmn/: jsmn.c
    ../../../../../middleware/third_party/aws_iot/platform/freertos/: aws_iot_timer.c network_mbedtls_wrapper.c threads_mutex_wrapper.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/shadow_sample/: shadow_sample.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/shadow_sample_console_echo/: shadow_console_echo.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/subscribe_publish_library_sample/: subscribe_publish_library_sample.c
    ../../../../../middleware/third_party/aws_iot/samples/freertos/subscribe_publish_sample/: subscribe_publish_sample.c
    ../../../../../middleware/third_party/aws_iot/src/: aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c
    ../../../../../middleware/third_party/aws_iot/tests/freertos_integration/multithreadingTest/: aws_iot_test_multithreading_validation.c
    ../../../../../middleware/third_party/aws_iot/tests/freertos_integration/src/: aws_iot_test_auto_reconnect.c aws_iot_test_basic_connectivity.c aws_iot_test_multiple_clients.c
  group connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_log.c connsys_util.c uart_slim_version.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver/board
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/board/mt76x7_hdk/util/src/: io_def.c
  group driver/chip
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_gpc.c hal_gpio_7687.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group iarfs
    $EW_DIR$/arm/src/lib/: close.c lseek.c open.c read.c remove.c write.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7687/: port_tick.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/service/offline_dump/src/: offline_dump.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/service/swla/src/: swla.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
    ../../../../../kernel/service/systemhang_tracer/src/: systemhang_tracer.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_log.c sys_arch.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aes_alt.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_hardware_poll.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md5_alt.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha1_alt.c sha256.c sha256_alt.c sha512.c sha512_alt.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c threading_alt.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../middleware/third_party/mbedtls/port/: porting_layer.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_IAR.a
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
  group project/app
    ../../../../../project/common/bsp_ex/src/: lp_ex_sleep.c
    ../../../../../project/mt7697_hdk/apps/aws_iot/src/: aws_iot_test.c ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c system_mt7687.c wifi_lwip_helper.c wifi_nvdm_config.c
    ./: startup_mt7687.s
  group wifi_service
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c single_rate_test.c wifi_bwcs_porting.c wifi_cm4_scan.c wifi_os_api.c wifi_profile.c wifi_repeater.c wifi_wps.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
