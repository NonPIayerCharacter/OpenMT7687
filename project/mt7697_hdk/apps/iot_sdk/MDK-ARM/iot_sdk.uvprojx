# Keil uVision project iot_sdk.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.2.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iot_sdk +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DATA_PATH_87 FREERTOS_ENABLE FREERTOS_VERSION=V10_AND_LATER MBEDTLS_CONFIG_FILE=<config-mtk-basic.h> MTK_AT_CMD_DISABLE MTK_BLE_BQB_CLI_ENABLE MTK_BLE_CLI_ENABLE MTK_BLE_SMTCN_ENABLE MTK_BSPEXT_ENABLE MTK_BT_LWIP_ENABLE MTK_CLI_FORK_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_DEBUG_LEVEL_ERROR MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_EXTERNAL_FLASH_ENABLE MTK_FLASH_DIRECT_DL MTK_FOTA_ENABLE MTK_FOTA_ON_7687 MTK_HAL_LOWPOWER_ENABLE MTK_HCI_CONSOLE_MIX_ENABLE MTK_HTTPCLIENT_SSL_ENABLE MTK_IPERF_ENABLE MTK_LWIP_ENABLE MTK_MINICLI_ENABLE MTK_MINISUPP_ENABLE MTK_NVDM_ENABLE MTK_OS_CLI_ENABLE MTK_PATCH_DL_ENABLE MTK_PING_OUT_ENABLE MTK_SINGLE_SKU_SUPPORT MTK_SMTCN_V5_ENABLE MTK_WIFI_CLI_ENABLE MTK_WIFI_PRIVILEGE_ENABLE MTK_WIFI_PROFILE_ENABLE MTK_WIFI_REPEATER_ENABLE PCFG_OS=2 PRODUCT_VERSION=7697 SUPPORT_MBEDTLS USE_HAL_DRIVER _REENT_SMALL __BT_DEBUG__ __MTK_BLE_ONLY_ENABLE__
  c misc: --C99
  c include: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\kernel\rtos\FreeRTOS;..\..\..\..\..\kernel\rtos\FreeRTOS\Source;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\service\offline_dump\inc;..\..\..\..\..\kernel\service\swla\inc;..\..\..\..\..\kernel\service\syslog\inc;..\..\..\..\..\kernel\service\systemhang_tracer\inc;..\..\..\..\..\middleware\MTK\bluetooth\inc;..\..\..\..\..\middleware\MTK\bt_callback_manager\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\dhcpd\inc;..\..\..\..\..\middleware\MTK\fota\inc;..\..\..\..\..\middleware\MTK\fota\inc\common;..\..\..\..\..\middleware\MTK\fota\inc\internal;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm_core\inc_core;..\..\..\..\..\middleware\MTK\smtcn\inc;..\..\..\..\..\middleware\MTK\smtcn\inc\internal;..\..\..\..\..\middleware\MTK\tftp\inc;..\..\..\..\..\middleware\MTK\verno\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\third_party\httpclient\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\lzma_decoder\inc;..\..\..\..\..\middleware\third_party\mbedtls\configs;..\..\..\..\..\middleware\third_party\mbedtls\include;..\..\..\..\..\middleware\third_party\micro_ecc\inc;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src;..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\FreeRTOS;..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\third_party\sntp\inc;..\..\..\..\..\middleware\third_party\xml\inc;..\..\..\..\..\prebuilt\middleware\MTK\bluetooth\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc\;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\project\mt7697_hdk\apps\iot_sdk\src\ut_app;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group app
    ../../../../../project/common/bsp_ex/src/: lp_ex_sleep.c
    ../../../../../project/mt7697_hdk/apps/iot_sdk/src/: ble_smtcn.c bt_init.c cli_cmds.c cli_def.c ept_eint_var.c ept_gpio_var.c hci_log.c main.c network_default_config.c nvdm_config.c regions_init.c sys_init.c system_mt7687.c wifi_lwip_helper.c wifi_nvdm_config.c
    ../../../../../project/mt7697_hdk/apps/iot_sdk/src/ut_app/: bt_lwip.c connection_info.c gatt_command.c gatt_service.c ut_app.c ut_app_gap.c
    ./: startup_mt7687.s
  group bluetooth
    ../../../../../middleware/MTK/bluetooth/src/: bt_cli.c bt_debug.c bt_hci_log.c bt_log.c bt_os_layer_api.c bt_task.c
    ../../../../../prebuilt/middleware/MTK/bluetooth/lib/: libble_CM4_keil.lib libble_multi_adv_CM4_keil.lib libbtdriver_7697_CM4_keil.lib
  group bt_callback_manager
    ../../../../../middleware/MTK/bt_callback_manager/src/: bt_callback_manager.c
  group connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_log.c connsys_util.c uart_slim_version.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver/board
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/board/mt76x7_hdk/util/src/: board_cli.c gpio_cli.c io_def.c
  group driver/chip
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_gpc.c hal_gpio_7687.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
  group fota
    ../../../../../middleware/MTK/fota/src/common/: fota_platform.c
    ../../../../../middleware/MTK/fota/src/: fota.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_cli.c fota_config.c fota_download_interface.c fota_internal.c fota_port.c
  group httpclient
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_cli.c iperf_task.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/service/swla/src/: swla.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
    ../../../../../kernel/service/systemhang_tracer/src/: systemhang_tracer.c
  group lwip
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c sys_arch.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: ethernet.c
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
  group mbedtls
    ../../../../../middleware/third_party/mbedtls/library/: aes.c aes_alt.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_hardware_poll.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md5_alt.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha1_alt.c sha256.c sha256_alt.c sha512.c sha512_alt.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c threading_alt.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../middleware/third_party/mbedtls/port/: porting_layer.c
  group micro_ecc
    ../../../../../middleware/third_party/micro_ecc/src/: uECC.c
  group minicli
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_Keil.lib
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_Keil.lib
  group mqtt
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/FreeRTOS/: MQTTFreeRTOS.c
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/: MQTTClient.c
    ../../../../../middleware/third_party/mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group n9
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group nghttp2
    ../../../../../middleware/third_party/nghttp2/lib/: nghttp2_buf.c nghttp2_callbacks.c nghttp2_debug.c nghttp2_frame.c nghttp2_hd.c nghttp2_hd_huffman.c nghttp2_hd_huffman_data.c nghttp2_helper.c nghttp2_http.c nghttp2_map.c nghttp2_mem.c nghttp2_net.c nghttp2_npn.c nghttp2_option.c nghttp2_outbound_item.c nghttp2_pq.c nghttp2_priority_spec.c nghttp2_queue.c nghttp2_rcbuf.c nghttp2_session.c nghttp2_stream.c nghttp2_submit.c nghttp2_version.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c ops_config.c smt_api.c smt_conn.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_Keil.lib libmcsmtcn_CM4_Keil.lib
  group sntp
    ../../../../../middleware/third_party/sntp/src/: sntp.c
  group tftp
    ../../../../../middleware/MTK/tftp/src/: port.c tftp.c tftpc.c
  group wifi_service
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c single_rate_test.c wifi_bwcs_porting.c wifi_cli.c wifi_cm4_scan.c wifi_inband_cli.c wifi_os_api.c wifi_private_cli.c wifi_profile.c wifi_repeater.c wifi_wps.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
