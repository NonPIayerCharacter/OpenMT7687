# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.7.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe --bin -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: INTERNAL_KEIL_LOAD BL_DEBUG MOD_CFG_FOTA_DISABLE_OS MOD_CFG_FOTA_DISABLE_CLI MOD_CFG_FOTA_BL_RESERVED BL_FOTA_DEBUG MTK_FOTA_ON_7687
  c misc: --c99
  c include: .\flash.sct;..\..\..\..\..\project\mt7697_hdk\apps\bootloader\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\fota\inc\internal\;..\..\..\..\..\middleware\MTK\fota\inc\common\;..\..\..\..\..\middleware\MTK\fota\inc\;..\..\..\..\..\driver\board\mt76x7_hdk\bootloader\src\mt7687\;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include\;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\middleware\third_party\lzma_decoder\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  group driver
    ../../../../../driver/board/mt76x7_hdk/bootloader/src/mt7687/: main.c hw_uart.c
    ../../../../../driver/chip/mt7687/src/: hal_gpio.c hal_uart.c hal_flash.c hal_sha.c hal_aes.c hal_cache.c hal_cache_internal.c hal_nvic.c hal_nvic_internal.c hal_log.c hal_gpt.c hal_wdt.c hal_eint.c
    ../../../../../driver/chip/mt7687/src/common/: low_hal_gpio.c hal_gpio_7687.c dma.c hal_pinmux.c pinmux.c nvic.c uart.c timer.c flash_sfc.c spi_flash.c gpt.c sfc.c top.c low_hal_wdt.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_utils.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group cmsis
    ../src/: system_mt7687.c
    ./: startup_mt7687.s
  group fota
    ../../../../../middleware/MTK/fota/src/common/: fota_platform.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_internal.c fota_config.c fota_port.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_protected_CM4_Keil.lib libhal_core_CM4_Keil.lib
  group ept
    ../src/: ept_eint_var.c ept_gpio_var.c
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
