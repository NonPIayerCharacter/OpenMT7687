# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BL_DEBUG; BL_FOTA_DEBUG; CFG_SUPPORT_SMNT_PROTO=2; MOD_CFG_FOTA_BL_RESERVED; MOD_CFG_FOTA_DISABLE_CLI; MOD_CFG_FOTA_DISABLE_OS; MTK_FOTA_ON_7687
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\board\mt76x7_hdk\bootloader\src\mt7687; ..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\middleware\MTK\fota\inc; ..\..\..\..\..\middleware\MTK\fota\inc\common; ..\..\..\..\..\middleware\MTK\fota\inc\internal; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\middleware\third_party\lzma_decoder\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkKeepSymbols: __isr_vector
  ILINK.IlinkIcfFile: mtk7697_flash.icf
  group cmsis
    ../src/: system_mt7687.c
    ./: startup_mt7687.s
  group driver
    ../../../../../driver/board/mt76x7_hdk/bootloader/src/mt7687/: hw_uart.c main.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/chip/mt7687/src/common/: dma.c flash_sfc.c gpt.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c low_hal_wdt.c nvic.c pinmux.c sfc.c spi_flash.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_aes.c hal_cache.c hal_cache_internal.c hal_flash.c hal_gpio.c hal_gpt.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_sha.c hal_uart.c hal_wdt.c
  group ept
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../src/: ept_eint_var.c ept_gpio_var.c
  group fota
    ../../../../../middleware/MTK/fota/src/common/: fota_platform.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_config.c fota_internal.c fota_port.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
