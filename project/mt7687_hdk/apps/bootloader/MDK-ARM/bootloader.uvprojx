# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.7.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe --bin -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BL_DEBUG BL_FOTA_DEBUG CFG_SUPPORT_SMNT_PROTO=2 INTERNAL_KEIL_LOAD MOD_CFG_FOTA_BL_RESERVED MOD_CFG_FOTA_DISABLE_CLI MOD_CFG_FOTA_DISABLE_OS MTK_FOTA_ON_7687
  c misc: --c99
  c include: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include\;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\mt76x7_hdk\bootloader\src\mt7687\;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\MTK\fota\inc\;..\..\..\..\..\middleware\MTK\fota\inc\common\;..\..\..\..\..\middleware\MTK\fota\inc\internal\;..\..\..\..\..\middleware\MTK\verno\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\third_party\lzma_decoder\inc;..\..\..\..\..\project\mt7687_hdk\apps\bootloader\inc;.\flash.sct
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  group cmsis
    ../src/: system_mt7687.c
    ./: startup_mt7687.s
  group driver
    ../../../../../driver/board/mt76x7_hdk/bootloader/src/mt7687/: hw_uart.c main.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/chip/mt7687/src/common/: dma.c flash_sfc.c gpt.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c low_hal_wdt.c nvic.c pinmux.c sfc.c spi_flash.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_aes.c hal_cache.c hal_cache_internal.c hal_eint.c hal_flash.c hal_gpio.c hal_gpt.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_sha.c hal_uart.c hal_wdt.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_utils.c
  group ept
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../src/: ept_eint_var.c ept_gpio_var.c
  group fota
    ../../../../../middleware/MTK/fota/src/common/: fota_platform.c
    ../../../../../middleware/MTK/fota/src/internal/: fota_config.c fota_internal.c fota_port.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
  group lzma_decoder
    ../../../../../middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
