# Keil uVision project xml.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.7.0
  cpu: IROM(0x10000000,0x00400000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xml
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: DATA_PATH_87 FREERTOS_ENABLE FREERTOS_VERSION=V10_AND_LATER MBEDTLS_CONFIG_FILE=<config-mtk-basic.h> MTK_BSPEXT_ENABLE MTK_DEBUG_LEVEL_DEBUG MTK_DEBUG_LEVEL_ERROR MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_EXTERNAL_FLASH_ENABLE MTK_FLASH_DIRECT_DL MTK_HAL_LOWPOWER_ENABLE MTK_HIF_GDMA_ENABLE MTK_IPERF_ENABLE MTK_LWIP_ENABLE MTK_MINISUPP_ENABLE MTK_NVDM_ENABLE MTK_PATCH_DL_ENABLE MTK_PING_OUT_ENABLE MTK_WIFI_CLI_ENABLE MTK_WIFI_TGN_VERIFY_ENABLE PCFG_OS=2 PRODUCT_VERSION=7687 USE_HAL_DRIVER _REENT_SMALL
  c misc: --c99 --diag_suppress=161 --diag_suppress=1295
  c include: ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc;..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc;..\..\..\..\..\driver\board\mt76x7_hdk\util\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\kernel\rtos\FreeRTOS;..\..\..\..\..\kernel\rtos\FreeRTOS\Source;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\kernel\service\offline_dump\inc;..\..\..\..\..\kernel\service\swla\inc;..\..\..\..\..\kernel\service\syslog\inc;..\..\..\..\..\kernel\service\systemhang_tracer\inc;..\..\..\..\..\middleware\MTK\connsys\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvdm_core\inc_core;..\..\..\..\..\middleware\MTK\verno\inc;..\..\..\..\..\middleware\MTK\wifi_service\combo\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes;..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2;..\..\..\..\..\middleware\third_party\xml\inc;..\..\..\..\..\prebuilt\middleware\MTK\minisupp\inc;..\..\..\..\..\project\mt7687_hdk\apps\xml\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector --keep N9_array
  group app
    ../../../../../project/mt7687_hdk/apps/xml/src/: ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c system_mt7687.c xml_test.c
    ./: startup_mt7687.s
  group driver/board
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group driver/chip
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_I2C.c hal_gpc.c hal_gpio_7687.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_des.c hal_dwt.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
    ../../../../../prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/mt7687/: port_tick.c
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/service/swla/src/: swla.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
    ../../../../../kernel/service/systemhang_tracer/src/: systemhang_tracer.c
  group minisupp
    ../../../../../prebuilt/middleware/MTK/minisupp/lib/: libminisupp_CM4_Keil.lib
  group n9
    ../../../../../tools/keil/mt7687/N9/: mt76X7_n9_image.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_KEIL.lib
  group wifi_service
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_Keil.lib
  group xml
    ../../../../../middleware/third_party/xml/src/: mxml-attr.c mxml-entity.c mxml-file.c mxml-get.c mxml-index.c mxml-node.c mxml-private.c mxml-search.c mxml-set.c mxml-string.c
